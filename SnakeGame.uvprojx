# Keil uVision project SnakeGame.uvprojx, settings and files
target TM4C123GH6PM (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SnakeGame
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\FreeRTOS\include;.\FreeRTOS\portable\GCC\ARM_CM4F;.\Includes\CMSIS;.\Includes\TM4C123;.\FreeRTOS\demo_code;.\Includes;.\Src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group FreeRTOS
    ./FreeRTOS/: queue.c tasks.c list.c timers.c
    ./FreeRTOS/portable/GCC/ARM_CM4F/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group Src
    ./Src/: main.c game.c uart.c gameTasks.c
software components: Device:Startup 1.0.1
